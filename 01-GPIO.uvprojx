# Keil uVision project 01-GPIO.uvprojx, settings and files
target 01-GPIO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF)   CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: 01-GPIO +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\SYSTEM;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x90000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group MDK-ARM
    ./: startup_stm32h750xx.s
  group App
    ../App/: led.c timer.c driver.c xyz_move.c operate.c flash.c hmi.c
  group SYSTEM
    ../SYSTEM/: sys.c delay.c usart1.c usart2.c
    ../App/: usart3.c
target 01-GPIO_W25Qxx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: 01-GPIO_W25Qxx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,W25Qxx
  c include: ../Core/Inc;   ../Drivers/STM32H7xx_HAL_Driver/Inc;   ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;   ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x90000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 4.3.0
